<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\5_threadX_netXduo.ewp</path>
  </project>
  <batchBuild />
</workspace>

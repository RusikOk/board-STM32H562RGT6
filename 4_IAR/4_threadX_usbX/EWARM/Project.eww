<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\4_threadX_usbX.ewp</path>
  </project>
  <batchBuild />
</workspace>
